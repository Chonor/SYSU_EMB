# Keil uVision project lab3-2.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM3S1968 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: lab3-2
  c flags: Optim=1
  c include: C:\Keil\EE319KwareSpring2016\driverlib;C:\Keil\EE319KwareSpring2016\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: Startup.s main.c
